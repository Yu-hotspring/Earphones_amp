# Repository Yu-hotspring/Earphones_amp

## KiCad design Earphones_amp.kicad_pcb

Parts:
BT1: 9V; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
C1, C2: 470u; CP_Radial_D16.0mm_P7.50mm
C3, C4: 0.22u; C_Rect_L7.2mm_W3.5mm_P5.00mm
C5, C6: 1u; C_Rect_L7.2mm_W6.0mm_P5.00mm
C7, C8: 0.022u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C9, C10: 0.1u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C11, C12: 2200p; C_Rect_L7.2mm_W2.5mm_P5.00mm
C13, C14: 0.01u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C15, C16, C17, C18, C19: 0.1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C20, C21: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1: LED; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
D2, D3: D; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2: AudioJack3; MJ352W
Q1: 2SC1815; TO-92L_Inline_Wide
Q2: 2SA1015; TO-92L_Inline_Wide
Q3, Q5, Q8, Q10: PNP; TO-92L_Inline_Wide
Q4, Q6, Q7, Q9: NPN; TO-92L_Inline_Wide
R1, R2, R3, R5, R6, R19, R20, R21, R22: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7, R8, R11, R12, R15, R16: 680; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R9, R10, R13, R14, R17, R18: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R23, R24: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R25, R26: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R27, R28, R29, R30: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R31, R32, R33, R34: 2.2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R35, R36: 22; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R37, R38: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1, RV2, RV3: 10k; SL4515G
RV4: 50k; RV_2C
SW1: SW_SPDT; SS12D00G3
U1: Opamp_Dual; DIP-8_W7.62mm_Socket
U2: TL072; DIP-8_W7.62mm_Socket
U3, U5: TL074; DIP-14_W7.62mm_Socket
U4: OPA1655DR; DIP-8_W7.62mm_Socket

Connections:
/V_{+}: C1.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, D1.2 (A), D2.1 (K), Q1.1 (C), Q4.2 (C), Q6.2 (C), Q7.2 (C), Q9.2 (C), R2.1, R27.1, R29.1, SW1.1 (A), U1.8 (V+), U2.8 (V+), U3.4 (V+), U4.8 (V+), U5.4 (V+)
/V_{-}: BT1.2 (-), C2.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, D3.2 (A), Q2.1 (C), Q3.2 (C), Q5.2 (C), Q8.2 (C), Q10.2 (C), R1.2, R3.2, R28.2, R30.2, U1.4 (V-), U2.4 (V-), U3.11 (V-), U4.4 (V-), U5.11 (V-)
/out_L: J2.T, R23.2, R35.2
/out_R: J2.R, R24.2, R36.2
/sigIN_L: J1.T, R37.1, U2.3 (+)
/sigIN_R: J1.R, R38.1, U2.5 (+)
GNDREF: C1.2, C2.1, C20.2, C21.1, D2.2 (A), D3.1 (K), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), J1.S, J2.S, Q1.3 (E), Q2.3 (E), R9.2, R10.2, R13.2, R14.2, R17.2, R18.2, R21.2, R22.2, R37.2, R38.2, RV4.3, RV4.6, U1.2 (-), U1.5 (+)
unnamed: BT1.1 (+), SW1.2 (B)
unnamed: C3.1, RV1.2
unnamed: C3.2, C5.1, R7.1
unnamed: C4.1, RV1.5
unnamed: C4.2, C6.1, R8.1
unnamed: C7.1, RV2.2
unnamed: C7.2, C9.1, R11.1
unnamed: C8.1, RV2.5
unnamed: C8.2, C10.1, R12.1
unnamed: C11.1, RV3.2
unnamed: C11.2, C13.1, R15.1
unnamed: C12.1, RV3.5
unnamed: C12.2, C14.1, R16.1
unnamed: D1.1 (K), R1.1
unnamed: Q1.2 (B), Q2.2 (B), R4.2
unnamed: Q3.3 (B), Q4.3 (B), R25.2
unnamed: Q3.1 (E), Q7.3 (B), R27.2
unnamed: Q4.1 (E), Q8.3 (B), R28.1
unnamed: Q5.3 (B), Q6.3 (B), R26.2
unnamed: Q5.1 (E), Q9.3 (B), R29.2
unnamed: Q7.1 (E), R31.1
unnamed: Q8.1 (E), R32.2
unnamed: Q9.1 (E), R33.1
unnamed: Q6.1 (E), Q10.3 (B), R30.1
unnamed: Q10.1 (E), R34.2
unnamed: R4.1, U1.1
unnamed: R19.2, RV4.4, U3.8
unnamed: R20.2, RV4.1, U5.14
unnamed: R25.1, U4.1
unnamed: R26.1, U4.7
unnamed: R31.2, R32.1, R35.1
unnamed: R33.2, R34.1, R36.1
unnamed: R2.2, R3.1, U1.3 (+)
unnamed: U1.6 (-), U1.7
unnamed: R5.1, U2.1, U2.2 (-)
unnamed: R6.1, U2.6 (-), U2.7
unnamed: C5.2, R9.1, U3.3 (+)
unnamed: R7.2, U3.1, U3.2 (-)
unnamed: C9.2, R13.1, U3.5 (+)
unnamed: R11.2, U3.6 (-), U3.7
unnamed: R5.2, RV1.3, RV2.3, RV3.3, U3.10 (+)
unnamed: R19.1, RV1.1, RV2.1, RV3.1, U3.9 (-)
unnamed: C13.2, R17.1, U3.12 (+)
unnamed: R15.2, U3.13 (-), U3.14
unnamed: RV4.5, U4.3 (+)
unnamed: R21.1, R23.1, U4.2 (-)
unnamed: RV4.2, U4.5 (+)
unnamed: R22.1, R24.1, U4.6 (-)
unnamed: C6.2, R10.1, U5.3 (+)
unnamed: R8.2, U5.1, U5.2 (-)
unnamed: C10.2, R14.1, U5.5 (+)
unnamed: R12.2, U5.6 (-), U5.7
unnamed: C14.2, R18.1, U5.10 (+)
unnamed: R16.2, U5.8, U5.9 (-)
unnamed: R6.2, RV1.6, RV2.6, RV3.6, U5.12 (+)
unnamed: R20.1, RV1.4, RV2.4, RV3.4, U5.13 (-)

Notes on the sheet:
10kHz
1kHz
バッファ
100Hz
駆動対象：KZ ZST インピーダンス：10[Ω] 感度S：106[dB/mW] 目標音圧L：115[dB] SPL 電力P=10^{(L-S)/10} =7.9[mW] 電圧V=root(P*R) =0.28[Vrms] =0.4[Vp-p] 電流I=V/R =28[mArms] 増幅率A=1+(Rb/Ra) =1.47 出力抵抗22[Ω] (ラインレベル1[Vp-p]として電圧増幅段で1.47倍，分圧されて0.46[Vp-p])

Board: 2 copper layers, 100.0 x 70.0 mm, 88 parts (1 on the bottom side), 63 nets.

## Commit log (part)

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2026-01-16 回路図Done LT->DT
2026-01-16 部品紐づけ進めた
2026-06-23 回路図完成
2026-06-23 PCBすすめた
2026-06-23 部品置いた
2026-06-26 gbr出力
2026-06-26 シルク追記，gbr更新
